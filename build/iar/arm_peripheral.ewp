# IAR project arm_peripheral.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER; DEBUG=1; _FLASH_PROG
  ICCARM.CCIncludePath2: ..\..\; ..\..\Inc; ..\..\library\CMSIS\Include; ..\..\library\STM32F10x_StdPeriph_Driver\inc; ..\..\rtos\embos\iar\inc; ..\..\Application\p-types
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: fw2
  ILINK.IlinkOutputFile: arm_peripheral.out
  ILINK.IlinkIcfFile: ..\..\setup\iar\flash.icf
  ILINK.IlinkAdditionalLibs: ..\..\rtos\embos\iar\lib\os7m_tl__d.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER; NDEBUG; _FLASH_PROG
  ICCARM.CCIncludePath2: ..\..\; ..\..\library\CMSIS\Include; ..\..\library\STM32F10x_StdPeriph_Driver\inc; ..\..\rtos\embos\iar\inc; ..\..\Inc; ..\..\Application\p-types
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  group Application
    ../../Application/: bt.c flash.c lcd_2x16.c log.c spi_slave.c Start.c sw_uart.c utils.c
  group Application/p-types
    ../../Application/: 18B20.c one_wire.c
  group Application/p-types/vending
    ../../Application/p-types/vending/: cashless.c dex.c dex_sample.c mdb.c mdb_sniffer.c pt-vending.c
  group Lib/rtos
    ../../rtos/embos/iar/lib/: os7m_tl__dp.a os7m_tl__r.a
  group Lib/STM32F10x_StdPeriph_Driver
    ../../library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Setup
    ../../rtos/embos/: BSP.c
    ../../rtos/embos/iar/setup/: JLINKMEM_Process.c OS_Error.c RTOSInit.c RTOSVect.c xmtx.c xmtx2.c

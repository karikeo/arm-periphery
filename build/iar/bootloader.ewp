# IAR project bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER; _FLASH_PROG; DEBUG=1; BOOTLOADER
  ICCARM.CCIncludePath2: ..\..\library\CMSIS\Include; ..\..\library\STM32F10x_StdPeriph_Driver\inc; ..\..\inc; ..\..\; ..\..\rtos\embos\iar\inc
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bootloader.srec
  ILINK.IlinkOutputFile: bootloader.out
  ILINK.IlinkIcfFile: ..\..\setup\iar\bootloader.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER; _FLASH_PROG; NDEBUG; BOOTLOADER
  ICCARM.CCIncludePath2: ..\..\; ..\..\Inc; ..\..\library\CMSIS\Include; ..\..\library\STM32F10x_StdPeriph_Driver\inc; ..\..\rtos\embos\iar\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  group (top)
    ../../Application/bootloader/: bootloader.c stm32f10x_it.c
    ../../Application/: lcd_2x16.c
  group Lib/STM32F10x_StdPeriph_Driver
    ../../library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c

# Keil uVision project arm_peripheral.uvprojx, settings and files
target vendicont-900E (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: arm_peripheral
  c flags: Optim=4 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,_FLASH_PROG,STM32F10X_HD
  c include: ..\..\;..\..\library\inc;..\..\inc;..\..\application;..\..\rtos\embos\keil\inc;..\..\application\p-types;..\..\library\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8004000 size 0x1c000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group startup
    ./: startup_stm32f10x_md.s
  group application
    ../../application/: 18B20.c flash.c lcd_2x16.c log.c one_wire.c spi_slave.c start.c
    ../../application/p-types/: pt-vending.c
  group rtos
    ../../rtos/embos/: BSP.c
    ../../rtos/embos/keil/setup/: JLINKMEM_Process.c OS_Error.c OS_InitSysStackInfo.c Retarget.c RTOSInit.c
    ../../rtos/embos/keil/lib/: osT7LD.lib osT7LR.lib
  group STM32F10x_StdPeriph_Driver
    ../../library/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
